## drivers/samsung/Kconfig
```kconfig
#
#
#

menu "Samsung Kernel Modules"

source "drivers/samsung/startup_reason/Kconfig"

endmenu
```
